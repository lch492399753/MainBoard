# Keil uVision project REMOTE.uvprojx, settings and files
target REMOTE (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: REMOTE +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\RTC;..\HARDWARE\RTC;..\HARDWARE\WKUP;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\DMA;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\SPI;..\HARDWARE\FLASH;..\HARDWARE\TOUCH;..\HARDWARE\REMOTE;..\HARDWARE\PWM;..\HARDWARE\GPIO;..\HARDWARE\EXTI;..\HARDWARE\ATK-ESP8266;..\HARDWARE\TONGXINJIEXI;..\HARDWARE\STMFLASH;..\HARDWARE\PID;..\HARDWARE\TACKING;..\HARDWARE\WTC7514DSI;..\HARDWARE\IIC;..\HARDWARE\AGVSensor;..\HARDWARE\iFlytek;..\Funs;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\MPU6050;..\HARDWARE\motor
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c user_config.h
    ../STM32F10x_FWLib/src/: stm32f10x_flash.c
  group HARDWARE
    ../HARDWARE/PWM/: pwm.c
    ../HARDWARE/GPIO/: GPIO.c
    ../HARDWARE/TONGXINJIEXI/: jiexi.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/PID/: PID.c
    ../HARDWARE/TACKING/: Tracking.c
    ../HARDWARE/WTC7514DSI/: wtc7514.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/AGVSensor/: AGV_Sensor.c
    ../HARDWARE/iFlytek/: iFlytek.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu.h inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/MPU6050/: mpu6050.c mpuiic.c
  group WIFI
    ../HARDWARE/ATK-ESP8266/: wifiap.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c ring_buffer.c
    ./: CmdPrase.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_exti.c
  group README
    ../: README.TXT
  group FUN
    ../Funs/: PoseWithVoice_Fun.c common.c obst.c
